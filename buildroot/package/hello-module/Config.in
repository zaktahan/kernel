## buildroot/package/hello-module/Config.in
```kconfig
config BR2_PACKAGE_HELLO_MODULE
    bool "Hello Kernel Module"
    depends on BR2_LINUX_KERNEL
    help
      My first Linux Kernel Module.
```
